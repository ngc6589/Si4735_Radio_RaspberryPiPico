# Repository ngc6589/Si4735_Radio_RaspberryPiPico

File readme.md:

# Si4735ラジオ概要

Raspberry Pi Pico と ILI9341 タッチ液晶を使用し、Si4735 DSP ラジオチップを動かすラジオを製作しました。写真のように周波数を入力してチューニングする画面、ステップ周波数のUP/DOWNチューニング、選局リストからチューニングのモードを備えています。
このラジオの Raspberry Pi Pico のファームウエアは micropython に lvgl グラフィックライブラリをバインドした lv_micropython というものを使用しています。この lv_micropython は https://github.com/lvgl/lv_micropython にて公開されています。これにフリーフォントなどを加えたカスタマイズ版のファームウエアを作成しています。
このファームウエアに micropython で記述したラジオアプリケーションを動かして上記機能を実現しました。

現在 MicroPython は 1.20 がリリースされましたが、lv_micropython はまだ 1.19 なので、当ラジオのファームウエアの MicroPython は 1.19 です。

## 資料

|フォルダ|用途|
|---|---|
|Application|Raspberry Pi Pico の Micro Python ローカルストレージに格納するファイルです|
|Doc|回路図の pdf と部品表のエクセルファイル|
|KiCad_RaspberryPiPico|Raspberry Pi Pico の KiCad ファイルです。ガーバーは pico-20230412 フォルダに入っています|
|KiCad_SP|マイクロスピーカーを着ける KiCad ファイルです。ガーバーは SP-20230412 フォルダに入っています|
|KiCad_Si4735|Si4735 の KiCad ファイルです。ガーバーは RD-20230412 フォルダに入っています。この基板は4層です。
|lv_micropython_Firmware|Raspberry Pi Pico の Flash に書き込む lv_micropython のファームウエアです。firmware.uf2 を書き込んで下さい。

KiCad ファイルはバージョンは 7.0.2 で作成しました。

## 制限事項

* 画面ハングアップ

Raspberry Pi Pico の RAMが 264kB なので画面にグラフィックスウイジェットをたくさん出すとハングアップします。特に選局リストは放送局分のオブジェクトを内部で作成するので、選局リストをいじくりまわしていると固まることが多いです。選局して放置している分には特にハングアップは発生しません。
画面が動かなくなった場合が液晶基板右上に白いタクトスイッチが付いてます。これは RESET スイッチです。これを押して再起動してください。

今後 lvgl や micropython の新バージョンがリリースされても改善の見込みはありません。

* 電源スイッチはありません
* 電源電圧は 5V です。 

Raspberry Pi Pico のUSB端子もしくはとDCジャックから給電します。同時挿しも問題ありません。DCジャックから給電する場合は 5V のスイッチング AC アダプタを使用してください。

トランス式 AC アダプタの場合は表示が 5V でも電源電圧が 5V 以上になっているため使用できません。ラジオのボードは壊れます。

* 放送受信状態は、ご使用になられる場所。アンテナなどの受信設備の違いなど。受信環境の変化要素が多いため一定の保証をすることは困難です。あらかじめご了承願います。

## 簡単な使用方法

### 周波数入力とステップチューニング切り替え

周波数入力選局とステップチューニング画面は、画面上の余白をロングタップすると切り替わります。

### 選局リスト表示

選局リストチューニングは画面をスワイプもしくは画面下部の Station を押すと画面遷移します。戻るときは画面下部の MAIN を押すか画面スワイプで戻ります。

選局リスト画面上部に 0 ～ 9 のボタンがあります。ボタンをクリックすると micropython 内部ファイルシステムに格納してある [0-9].txt のファイルをリードして画面に表示します。

選局したい局の行をクリックするとその放送局にチューニングします。

### 周波数入力チューニング

周波数入力する時は「Ｃ」ボタンを押して、周波数表示が消えた状態で数字を入れて「ｋ」か「Ｍ」ボタンをクリックして選局します。
入力途中で「Ｃ」を押すと元の周波数表示に戻ります。
「＜＜」「＞＞」はシークチューニングです。シーク後放送局が見つかるとシーク動作は停止します。

### ステップチューニング

周波数表示の下に選択可能な周波数ステップボタンが表示されています。画面下部の「<<」「>>」1回クリックすると指定されたステップでチューニングします。長押しで連続ステップチューニング動作をします。

## AMモードゲインボリューム

LW/MW/SW 受信時は SMA コネクタの後に 3SK291 を使用した1石高周波増幅回路を搭載しています。増幅率は左側面アンテナコネクタ近くにボリウムを設けています。このボリウムを回して放送の聞こえ具合を調整してください。左に回し切ると1石増幅器は停止し、放送は聞こえなくなります。右に回し切るとお住まいの電波環境にもよりますが複数の局が混信して聞こえることがあります。

## アンテナ端子について

正面から見て左が LW/MW/SW 用で右が FM 放送用のアンテナ端子です。アンテナ端子の形状は SMA タイプです。

## I2S 出力端子について

2023年6月21日以前に購入された方は、I2S 出力ピンヘッダ横のダンピング抵抗 R1, R2, R3 を 100Ωに変えていただくことでビットクロックなどの波形が安定します。

|端子名|備考|
|-|-|
|BCLK|ビットクロック|
|DATA|データ|
|LRCK|LRクロック|
|GND|グランド|
|NC|未接続|
|VCC|5V出力 3.3vではありません|

I2S 出力するときは、プログラムのラジオチップ初期化のコマンドを I2S 出力対応にする必要があります。

```
# Generate 48k I2S clock
# uncomment I2S OUTPUT
# @rp2.asm_pio(
#     sideset_init=(rp2.PIO.OUT_HIGH, rp2.PIO.OUT_HIGH)
# )
# def gen48k():
#     set(x, 30)       .side(0b00) [1]
#     nop()            .side(0b01) [1]
#     label("L01")
#     nop()            .side(0b00) [1]
#     jmp(x_dec, "L01").side(0b01) [1]
#     set(x, 30)       .side(0b10) [1]
#     nop()            .side(0b11) [1]
#     label("R01")
#     nop()            .side(0b10) [1]
#     jmp(x_dec, "R01").side(0b11) [1]
# 
# sm0 = rp2.StateMachine(
#     0,
#     gen48k,
#     freq=12_288_000,
#     sideset_base=machine.Pin(4)
# )
# sm0.active(1)
```

のコメントを外します。
また、

```
    def FMPOWER_UP(self):
        self.i2c.writeto(self.addr, bytes([0x01, 0x00, 0x05]))  # analog Out
#         self.i2c.writeto(self.addr, bytes([0x01, 0x00, 0xB0]))   # I2S
        self.waitCTS()
        time.sleep(0.5)
        self.setProperty(bytes([0xFF, 0x00, 0x00, 0x00]))          # Turn off Debug Mode
#         self.setProperty(bytes([0x01, 0x04, 0xBB, 0x80]))        # I2s sample rate
```
```
    def AMPOWER_UP(self):
        self.i2c.writeto(self.addr, bytes([0x01, 0x01, 0x05])) # analog out
#         self.i2c.writeto(self.addr, bytes([0x01, 0x01, 0xB0]))  # I2S
        self.waitCTS()
        time.sleep(0.5)
        self.setProperty(bytes([0xFF, 0x00, 0x00, 0x00]))         # Turn off Debug Mode
#         self.setProperty(bytes([0x01, 0x04, 0xBB, 0x80]))       # I2S sample rate
```
の # analog out の行をコメントアウトして i2s のコメントを外すと I2S 出力になります。

デフォルトは 16bit/48k になります。

# プログラム更新

## thonny IDE
今回、ラジオのアプリケーション作成には 
Thonny Python IDE for beginners

https://thonny.org/

で、公開されている IDE を使用しています。
プログラムの修正などしてみる場合はこれをインストールして Si4735Radio の USB 接続すれば lv_micropython の REPL が使えるようになります。

ローカルのファイルを lv_micropython のファイルシステムにコピーしたりその逆も可。ファイルの修正も可能です。

## ファームウエア更新

液晶基板上側両再度に白いタクトスイッチが左右2個付いています。右がリセット・左がBOOTです。

「左BOOT」「右RESET」 両方押す

「右RESET」 離す

「左BOOT」 離す

この後 Raspberry Pi Pico は USB メモリモードになってホスト側PCのファイルに RPI PICO のドライブが使えるようになります。ここに .uf2 ファイルのドラッグ・ドロップ(コピーペースト)すればファームウエアの更新が可能です。

## KiCad design KiCad_Si4735/KiCad-Si4735.kicad_pcb

Parts:
C1: 100uF/25V; CP_Elec_6.3x7.7
C2, C12, C16: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 0.022uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C6: 0.01uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 0.47uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7: 1000pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8, C9: 12pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C10, C13: 47uF; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C11, C15, C23: 10p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14, C18, C20, C22: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C17, C21: 330uF/6.3V; CP_Radial_D8.0mm_P2.50mm
C19: 2.2uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: 1N5819HW; D_SOD-123
D2, D3, D4, D5, D6, D7: 1N4148W; D_SOD-123
EMI1, EMI2, EMI3, EMI4, EMI5: 4.7uF/6.3V; YFF18PC
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: I2SOUT; PinHeader_1x06_P2.54mm_Horizontal
J2: 5V; MJ-179PH
J3: Conn_02x08_Odd_Even; PinHeader_2x08_P2.54mm_Vertical
J4: AM/SW; SMA-J-P-H-ST-EM1
J5: FM; SMA-J-P-H-ST-EM1
J6: Phone OUT; MJ-352W-0
JP1: BCLK; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
JP2: RCLK; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
JP3, JP4: XTAL; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
L1: FT37-77 12T; FT37
L2: 270nH; L2
LS1: Speaker; PinHeader_1x02_P2.54mm_Horizontal
Q1: 3SK291; SOT-143_Handsoldering
R1: 620; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3: 2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 10; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 22k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6: 91k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 39k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R16, R17: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R14, R15, R19, R20: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R18: 33k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R13: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1: 10k; RV100F
RV2: 10k; 3306W
U1: Si4735-D60-GU; SSOP-24_3.9x8.7mm_P0.635mm
U2: TPA711DR; SO-8_3.9x4.9mm_P1.27mm
U3: TPA6111A2DR; SO-8_3.9x4.9mm_P1.27mm
Y1: 32.768kHz; FC-135

Connections:
3V3: EMI1.1, J3.8, J3.10, R19.1, R20.1
/GP4: J3.15, R3.1
/GP5: J3.13, R2.1
/GP6: J3.11, JP2.2 (B)
/GP20: J3.9, U1.18 (SDIO)
/GP21: J3.7, U1.17 (SCLK)
/GP22: J3.5, U1.15 (~RST)
/GP26: J3.3, R19.2, U2.1 (SHDN)
/GP27: J3.1, R20.2, U3.5 (SHDN)
/GP28: J3.2
GND: C1.2, C2.2, C4.1, C8.2, C9.2, C10.1, C12.1, C13.1, C16.1, C19.2, C22.2, D2.2 (A), D3.1 (K), D4.2 (A), D5.1 (K), D6.2 (A), D7.1 (K), EMI1.2, EMI2.2, EMI3.2, EMI4.2, EMI5.2, J1.4, J2.2, J2.3, J3.12, J3.14, J3.16, J4.2 (Ext), J5.2 (Ext), J6.S, L2.2, Q1.4 (S), R7.2, R8.2, R16.2, R17.2, RV1.1, RV2.1, U1.9 (RFGND), U1.13 (GND), U1.14 (GND), U2.3 (SE/~BTL), U2.7 (GND), U3.4 (GND)
LOUT: C18.1, U1.24 (LOUT/[DFS])
unnamed: C4.2, L1.1, R4.2
unnamed: C14.1, RV2.3
unnamed: C14.2, R10.1
unnamed: C17.2, J6.T, R16.1
unnamed: C18.2, R14.1
unnamed: C20.2, R15.1
unnamed: C21.2, J6.R, R17.1
unnamed: D1.2 (A), J2.1
unnamed: C6.2, D2.1 (K), D3.2 (A), J4.1 (In)
unnamed: C7.2, D4.1 (K), D5.2 (A), J5.1 (In)
unnamed: C5.1, D6.1 (K), D7.2 (A), U1.12 (AMI)
unnamed: EMI3.3, R4.1, R6.1, RV1.3
unnamed: J1.1, JP1.2 (B), R3.2
unnamed: J1.2, R1.2
unnamed: J1.3, R2.2, U1.2 (DFS)
unnamed: J6.RN, R12.1
unnamed: J6.TN, R13.1
unnamed: JP1.1 (A), JP4.2 (B), U1.3 (GPO3/[DCLK])
unnamed: JP2.1 (A), JP3.2 (B), U1.19 (RCLK)
unnamed: C8.1, JP3.1 (A), Y1.1
unnamed: C9.1, JP4.1 (A), Y1.2
unnamed: C5.2, L1.2, Q1.3 (D)
unnamed: C6.1, Q1.1 (G1), R6.2, R7.1
unnamed: Q1.2 (G2), R5.2, R8.1
unnamed: R5.1, RV1.2
unnamed: R12.2, R13.2, RV2.2
unnamed: C3.2, U1.22 (DBYP)
unnamed: R1.1, U1.1 (DOUT)
unnamed: C7.1, L2.1, U1.8 (FMI)
unnamed: C3.1, EMI2.3, U1.21 (VA)
unnamed: C2.1, EMI1.3, U1.16 (~SEN), U1.20 (VD)
unnamed: C19.1, U2.2 (BYPASS)
unnamed: C11.1, R9.2, R10.2, U2.4 (IN)
unnamed: C10.2, C12.2, EMI5.1, U2.6 (VDD)
unnamed: C11.2, LS1.1, R9.1, U2.5 (VO+)
unnamed: LS1.2, U2.8 (VO-)
unnamed: C22.1, U3.3 (BYPASS)
unnamed: C15.1, R11.1, R14.2, U3.2 (IN1-)
unnamed: C23.1, R15.2, R18.2, U3.6 (IN2-)
unnamed: C13.2, C16.2, EMI4.3, U3.8 (VDD)
unnamed: C15.2, C17.1, R11.2, U3.1 (VO1)
unnamed: C21.1, C23.2, R18.1, U3.7 (VO2)
ROUT: C20.1, U1.23 (ROUT/[DOUT])
VSYS: C1.1, D1.1 (K), EMI2.1, EMI3.1, EMI4.1, EMI5.3, J1.6, J3.4, J3.6

Notes on the sheet:
G1=1.5V G2=0 ~ 4V
LRCK
GND
Si4735 RESET
ロッドアンテナ
DATA
I2S BITCLK
+5V
Si4735 SCK
Si4735 RCLK
~{MUTE}
BCLK
0.5mm 鉛筆 6T
Si4735 SDA
AMP SHUTDOWN
I2S LRCLK

Board: 4 copper layers, 50.0 x 86.0 mm, 79 parts (1 on the bottom side), 55 nets.

File Doc/PartsList.xlsx:

| ■Raspberry Pi Pico board
 | Reference(s) | Qty | Value | ITEM NUMBER | LINK
 | U1 | 1 | Raspberry Pi Pico | M-16132 | https://akizukidenshi.com/catalog/g/gM-16132/
 | LCD1 | 1 | MSP2807_ILI9341_2.8_SPI | M-16265 | https://akizukidenshi.com/catalog/g/gM-16265/
 | J1 | 1 | Pin Header 2x8 | C-00082 | https://akizukidenshi.com/catalog/g/gC-00082/
 | J2, J3 **1 | 2 | Pin Header 1x3 R/A
 | R1, R2 | 2 | 4.7k SMD 0603(1608) | 541-5454-1-ND | https://www.digikey.jp/ja/products/detail/vishay-dale/CRCW06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
 | R3, R4, R5, R6 | 4 | 100 SMD 0603(1608) | 541-3951-1-ND | https://www.digikey.jp/ja/products/detail/vishay-dale/CRCW06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
 | R7, R8, R9, R10, R11, R12, R13, R14, R15 | 9 | 51 SMD 0604(1608) | 541-51.0HCT-ND | https://www.digikey.jp/ja/products/detail/vishay-dale/CRCW06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
 | SW1, SW2 | 2 | TACTILE SWITCH | P-14890 | https://akizukidenshi.com/catalog/g/gP-14890/
 |  |  |  | 679-2400-ND | https://www.digikey.jp/ja/products/detail/apem-inc/MJTP1117/1795496
 | ■Si4735 Board
 | Reference(s) | Qty | Value
 | U1 | 1 | Si4735-D60-GU | 336-2140-ND | https://www.digikey.jp/ja/products/detail/skyworks-solutions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
 | U2 | 1 | TPA711DR | 296-1950-1-ND | https://www.digikey.jp/ja/products/detail/texas-instruments/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
 | U3 | 1 | TPA6111A2DR | 296-10846-1-ND | https://www.digikey.jp/ja/products/detail/texas-instruments/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
 | Q1 | 1 | 3SK291 | I-10827 | https://akizukidenshi.com/catalog/g/gI-10827/
 | C1 | 1 | 100uF/25V SMD 6.3x7.7 | P-14452 | https://akizukidenshi.com/catalog/g/gP-14452/
 | C2, C12, C16 | 3 | 0.1uF SMD 0603(1608) | P-16143 | https://akizukidenshi.com/catalog/g/gP-16143/
 | C3 | 1 | 0.022uF X7R SMD 0603(1608) | 587-3503-1-ND | https://www.digikey.jp/ja/products/detail/taiyo-yuden/UMK107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
 | C4, C6 | 2 | 0.01uF SMD 0603(1608) | P-13387 | https://akizukidenshi.com/catalog/g/gP-13387/
 | C5 | 1 | 0.47uF X7R SMD 0603(1608) | 587-3170-1-ND | https://www.digikey.jp/ja/products/detail/taiyo-yuden/UMK107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
 | C7 | 1 | 1000pF SMD 0603(1608) | P-02332 | https://akizukidenshi.com/catalog/g/gP-02332/
 | C10, C13 | 2 | 47uF SMD 1210(3225) | P-16078 | https://akizukidenshi.com/catalog/g/gP-16078/
 | C11, C15, C23 | 3 | 10p SMD 0603(1608) | P-05520 | https://akizukidenshi.com/catalog/g/gP-05520/
 | C14, C18, C20, C22 | 4 | 1uF X7R SMD 0603(1608) | P-14526 | https://akizukidenshi.com/catalog/g/gP-14526/
 | C17, C21 | 2 | 330uF/6.3V D=8mm PITCH=2.5mm | P-08374 | https://akizukidenshi.com/catalog/g/gP-08374/
 | C19 | 1 | 2.2uF SMD 0603(1608) | P-16077 | https://akizukidenshi.com/catalog/g/gP-16077/
 | D1 | 1 | 1N5819HW SOD-123 | 1N5819HW-FDICT-ND | https://www.digikey.jp/ja/products/detail/diodes-incorporate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
 | D2, D3, D4, D5, D6, D7 | 6 | 1N4148W SOD-123 | I-07084 | https://akizukidenshi.com/catalog/g/gI-07084/
 | EMI1, EMI2, EMI3, EMI4, EMI5 | 5 | 4.7uF/6.3V FEEDTHRU 0603(1608) | 445-7080-1-ND | https://www.digikey.jp/ja/products/detail/tdk-corporation/YF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
 | J1 **1 | 1 | Pin Header 1x6 R/A
 | J2 | 1 | DC JACK MJ-179P | C-00077 | https://akizukidenshi.com/catalog/g/gC-00077/
 | J3 | 1 | Pin Socket 2x8 | C-02761 | https://akizukidenshi.com/catalog/g/gC-02761/
 | J4, J5 | 2 | AM/SW, FM | C-13195 | https://akizukidenshi.com/catalog/g/gC-13195/
 | J6 | 1 | MJ-352W-C | C-17359 | https://akizukidenshi.com/catalog/g/gC-17359/
 | L1 | 1 | FT37-77 (5977000201) 12T | 1934-1032-ND | https://www.digikey.jp/ja/products/detail/fair-rite-products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
 | R1 | 1 | 600 SMD 0603(1608) | 541-5512-1-ND | https://www.digikey.jp/ja/products/detail/vishay-dale/CRCW06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
 | R2, R3 | 2 | 2k SMD 0603(1608) | 541-3953-1-ND | https://www.digikey.jp/ja/products/detail/vishay-dale/CRCW06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
 | R4 | 1 | 10 SMD 0603(1608) | 541-3952-1-ND | https://www.digikey.jp/ja/products/detail/vishay-dale/CRCW06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
 | R5 | 1 | 22k SMD 0603(1608) | 541-4036-1-ND | https://www.digikey.jp/ja/products/detail/vishay-dale/CRCW06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
 | R6 | 1 | 91k SMD 0603(1608) | 541-5595-1-ND | https://www.digikey.jp/ja/products/detail/vishay-dale/CRCW06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
 | R7 | 1 | 39k SMD 0603(1608) | 541-5383-1-ND | https://www.digikey.jp/ja/products/detail/vishay-dale/CRCW06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
 | R8, R16, R17 | 3 | 100k SMD 0603(1608) | 541-3950-1-ND | https://www.digikey.jp/ja/products/detail/vishay-dale/CRCW06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
 | R9 | 1 | 47k SMD 0603(1608) | 541-4021-1-ND | https://www.digikey.jp/ja/products/detail/vishay-dale/CRCW06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
 | R10, R14, R15, R19, R20 | 5 | 10k SMD 0603(1608) | 541-5136-1-ND | https://www.digikey.jp/ja/products/detail/vishay-dale/CRCW06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
 | R11, R18 | 2 | 33k SMD 0603(1608) | 541-4041-1-ND | https://www.digikey.jp/ja/products/detail/vishay-dale/CRCW06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
 | R12, R13 | 2 | 1k SMD 0603(1608) | 541-3949-1-ND | https://www.digikey.jp/ja/products/detail/vishay-dale/CRCW06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
 | RV1 | 1 | 10k | P-14937 | https://akizukidenshi.com/catalog/g/gP-14937/
 |  |  |  | 312-1001F-10K | https://www.mouser.jp/ProductDetail/Alpha-Taiwan/RV100F-30-4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
 | RV2 | 1 | 10k TRIMMER | 3306W-103-ND | https://www.digikey.jp/ja/products/detail/bourns-inc/3306W-1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
 | LS1 **1 | 1 | 1x2 Pin Header
 | LS1 | 1 | MICRO SPEAKER | P-12495 | https://akizukidenshi.com/catalog/g/gP-12495/
 | ■Si4735 Crystal Option
 | Reference(s) | Qty | Value
 | Y1 | 1 | 32.768kHz 3.2×1.5×0.80mm | P-07195 | https://akizukidenshi.com/catalog/g/gP-07195/
 | C8, C9 | 2 | 12pF C0G SMD 0603(1608) | 399-CBR06C120J5GACCT-ND | https://www.digikey.jp/ja/products/detail/kemet/CBR06C120J5G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
 | ■screw / other
 | Reference(s) | Qty | Value
 | M3 Screw 4mm | 8 | plastic screws M3 Length 4mm | N-0304 | https://www.hirosugi-net.co.jp/shop/g/g35880/
 | M3 Spacer 6mm | 8 | Duracon spacer M3 Length 6mm | BS-306E | https://www.hirosugi-net.co.jp/shop/g/g3761/
 | M3 Spacer 11mm | 4 | Duracon spacer M3 Length 11mm internal thread | AS-311 | https://www.hirosugi-net.co.jp/shop/g/g3724/
 | **1
 | Pin Header 1x40 R/A | 1 | Pin Head 1x40 R/A | C-01627 | https://akizukidenshi.com/catalog/g/gC-01627/

## KiCad design KiCad_SP/KiCad_SP.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
H5, H6, H7, H8, H9, H10, H11: MountingHole; MountingHole_2.5mm
J1: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Horizontal
TP1, TP2: TestPoint; TestPoint_THTPad_1.0x1.0mm_Drill0.5mm

Connections:
unnamed: J1.1, TP1.1
unnamed: J1.2, TP2.1

Board: 2 copper layers, 50.0 x 86.0 mm, 14 parts (0 on the bottom side), 2 nets.

## KiCad design KiCad_RaspberryPiPico/KiCad.kicad_pcb

Parts:
C1: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Conn_02x08_Odd_Even; PinHeader_2x08_P2.54mm_Vertical
J2: DEBUG; PinSocket_1x03_P2.54mm_Horizontal
J3: UART; PinSocket_1x03_P2.54mm_Horizontal
LCD1: MSP2807_ILI9341_2.8_SPI; PinSocket_1x14_P2.54mm_Vertical
R1, R2: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R5, R6: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8, R9, R10, R11, R12, R13, R14, R15: 51; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: RESET; THBP07-043CW
SW2: BOOT; THBP07-043CW
U1: Pico; RPi_Pico_SMD_TH

Connections:
/3V3: C1.1, J1.8, J1.10, LCD1.1 (VCC), R1.1, R2.1, U1.36 (3V3)
/3V3_EN: U1.37 (3V3_EN)
/ADC_VREF: U1.35 (ADC_VREF)
/GP0: R3.2, U1.1 (GPIO0)
/GP1: R4.2, U1.2 (GPIO1)
/GP2: U1.4 (GPIO2)
/GP3: U1.5 (GPIO3)
/GP4: J1.15, U1.6 (GPIO4)
/GP5: J1.13, U1.7 (GPIO5)
/GP6: J1.11, U1.9 (GPIO6)
/GP7: U1.10 (GPIO7)
/GP8: R8.1, U1.11 (GPIO8)
/GP9: R7.1, U1.12 (GPIO9)
/GP10: R10.1, U1.14 (GPIO10)
/GP11: R9.1, U1.15 (GPIO11)
/GP12: R11.1, U1.16 (GPIO12)
/GP13: LCD1.8 (LED), U1.17 (GPIO13)
/GP14: U1.19 (GPIO14)
/GP15: LCD1.4 (~RESET), U1.20 (GPIO15)
/GP16: R13.1, U1.21 (GPIO16)
/GP17: R12.1, U1.22 (GPIO17)
/GP18: R14.1, U1.24 (GPIO18)
/GP19: R15.1, U1.25 (GPIO19)
/GP20: J1.9, R1.2, U1.26 (GPIO20)
/GP21: J1.7, R2.2, U1.27 (GPIO21)
/GP22: J1.5, U1.29 (GPIO22)
/GP26: J1.3, U1.31 (GPIO26_ADC0)
/GP27: J1.1, U1.32 (GPIO27_ADC1)
/GP28: J1.2, U1.34 (GPIO28_ADC2)
/RUN: SW1.1, U1.30 (RUN)
/SWCLK: J2.1, R5.1
/SWDIO: J2.3, R6.1
/UART0_RX: J3.3, R4.1
/UART0_TX: J3.1, R3.1
/VBUS: U1.40 (VBUS)
/VSYS: J1.4, J1.6, U1.39 (VSYS)
GND: C1.2, J1.12, J1.14, J1.16, J2.2, J3.2, LCD1.2 (GND), SW1.2, SW1.3, SW1.4, SW2.2, SW2.3, SW2.4, U1.3 (GND), U1.8 (GND), U1.13 (GND), U1.18 (GND), U1.23 (GND), U1.28 (GND), U1.33 (AGND), U1.38 (GND), U1.42 (GND)
unnamed: LCD1.5 (DC/RS), R8.2
unnamed: LCD1.9 (MISO), R11.2
unnamed: LCD1.6 (MOSI), R9.2
unnamed: LCD1.7 (SCK), R10.2
unnamed: LCD1.10 (T_CLK), R12.2
unnamed: LCD1.11 (T_CS), R13.2
unnamed: LCD1.12 (T_DIN), R14.2
unnamed: LCD1.13 (T_DO), R15.2
unnamed: LCD1.3 (~CS), R7.2
unnamed: R5.2, U1.41 (SWCLK)
unnamed: R6.2, U1.43 (SWDIO)
unnamed: SW2.1, U1.44 (TP6)

Notes on the sheet:
Si4735 SCK
TP MISO
Si4735 RESET
Si4735 SDA
Si4735 RCLK
TP CS
I2S LRCLK
LCD LED
MUTE
I2S BITCLK
LCD DC
LCD CS
LCD RESET
TP MOSI
LCD MISO
LCD MOSI
LCD SCK
TP SCK

Board: 2 copper layers, 50.0 x 86.0 mm, 27 parts (0 on the bottom side), 42 nets.

## Commit log

2023-03-28 add readme.md
2023-03-28 add Materials
2023-05-02 update schematic and add KiCad Files
2023-05-05 add PartsList.xlsx
2023-05-05 modify PartList.xlsx
2023-05-07 modify PartList
2023-06-21 add MicroPython 1.20.0 firmware
2023-06-21 remove firmware files
2023-06-21 change R1, R2, R3 100ohm
2023-06-21 update R1, R2, R3 to 100ohm
